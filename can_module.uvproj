# Keil uVision project can_module.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: can_module +hex
  c flags: Optim=3
  c define: STM32F10X_MD
  c include: .\src\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./src/: main.c Retarget.c RTX_Conf.c startup_stm32f10x_md.s
  group lib
    ./src/lib/: system_stm32f10x.c core_cm3.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_can.c
